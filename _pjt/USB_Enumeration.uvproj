# Keil uVision project USB_Enumeration.uvproj, settings and files
target Enumeration (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: USB_Enumeration +hex
  AfterMake: fromelf --bin ../USB_Enumeration.axf -o ./FW_OSLess_YYYYMMDD_V1.2.bin
  c flags: Optim=1 uC99=1
  c include: ..\Usb_hsic
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x28000 size 0x58000
  group _startup
    ../_startup/: tc9560_fw_start.s
  group Usb_hsic
    ../Usb_hsic/: dwc_common_neu.c dwc_otg_cil.c dwc_otg_cil_intr.c dwc_otg_driver.c dwc_otg_pcd.c dwc_otg_pcd_intr.c dwc_otg_pcd_linux.c USB_enu_main.c DWC_ETH_QOS_dev.c net_dev_neu.c tc9560_exception.c tc9560_gpio.c tc9560_uart.c
